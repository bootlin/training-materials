FILESEXTRAPATHS:prepend := "${THISDIR}/busybox:"
DEPENDS:append  = " libselinux"

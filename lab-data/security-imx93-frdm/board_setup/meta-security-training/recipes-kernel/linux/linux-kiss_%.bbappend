inherit kernel-fitimage

FILESEXTRAPATHS:prepend := "${THISDIR}/linux-kiss:"
